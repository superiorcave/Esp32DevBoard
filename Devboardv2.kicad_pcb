# Repository superiorcave/Esp32DevBoard

File README.md:

# Esp32DevBoard
An custom esp32 wroom devboard.

I used a custom ESP32-S3-Wroom-1 to create this project. This has all of the capabilities of a normal esp32, but with a custom pcb, 3 LEDS, and a cyberpunk logo. 

View my journal below
Journal: https://blueprint.hackclub.com/projects/1868

To Order the PCB you need to click on production and download "Devboardv2.zip" and upload that as the gerber file.
When ordering the part of JLCPCB, select PCB Assembly and make sure that part selection is by JLCPCB. 

### Image with 3D viewer:

### Schematic ScreenShot

### PCB ScreenShot

### Image of final product soon to be added

## KiCad design Devboardv2.kicad_pcb

Parts:
C1, C5: 10uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 22uf; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3, C4: 100nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J2, J3: Conn_01x20_Pin; PinHeader_1x20_P2.00mm_Vertical
R1, R2, R3, R4: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; SW_SPST_B3S-1000
U1: ESP32-S3-WROOM-1
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C2.1, C3.1, J2.2, R3.1, R5.1, U1.2 (3V3), U2.2 (VO)
+5V: C4.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J3.1, R2.1, U2.3 (VI)
D+: J1.A6 (D+), J1.B6 (D+), J2.14, U1.14 (USB_D+)
D-: J1.A7 (D-), J1.B7 (D-), J2.13, U1.13 (USB_D-)
EN: C5.1, J2.3, R5.2, SW2.2, U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), D3.1 (K), J1.A1 (GND), J1.A5 (CC1), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, R1.2, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.1 (GND)
GPIO0: J3.14, SW1.2, U1.27 (IO0)
GPIO1: J3.2, U1.39 (IO1)
GPIO2: J3.3, U1.38 (IO2)
GPIO3: J2.15, U1.15 (IO3)
GPIO4: J2.4, U1.4 (IO4)
GPIO5: J2.5, U1.5 (IO5)
GPIO6: J2.6, U1.6 (IO6)
GPIO7: J2.7, U1.7 (IO7)
GPIO8: J2.12, U1.12 (IO8)
GPIO9: J2.17, U1.17 (IO9)
GPIO10: J2.18, U1.18 (IO10)
GPIO11: J2.19, U1.19 (IO11)
GPIO12: J2.20, U1.20 (IO12)
GPIO13: J3.20, U1.21 (IO13)
GPIO14: J3.19, U1.22 (IO14)
GPIO15: J2.8, U1.8 (IO15)
GPIO16: J2.9, U1.9 (IO16)
GPIO17: J2.10, U1.10 (IO17)
GPIO18: J2.11, U1.11 (IO18)
GPIO21: J3.18, R4.1, U1.23 (IO21)
GPIO35: J3.13, U1.28 (IO35)
GPIO36: J3.12, U1.29 (IO36)
GPIO37: J3.11, U1.30 (IO37)
GPIO38: J3.10, U1.31 (IO38)
GPIO39: J3.9, U1.32 (IO39)
GPIO40: J3.8, U1.33 (IO40)
GPIO41: J3.7, U1.34 (IO41)
GPIO42: J3.6, U1.35 (IO42)
GPIO43: J3.4, U1.37 (TXD0)
GPIO44: J3.5, U1.36 (RXD0)
GPIO45: J3.15, U1.26 (IO45)
GPIO46: J2.16, U1.16 (IO46)
GPIO47: J3.17, U1.24 (IO47)
GPIO48: J3.16, U1.25 (IO48)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: J1.B5 (CC2), R1.1

Board: 2 copper layers, 37.9 x 62.0 mm, 20 parts (0 on the bottom side), 44 nets.

## Commit log

2025-11-26 Update README with project details
    Added project details about the custom ESP32-S3-Wroom-1.
2025-11-26 Production Files added: Use these to order PCB
2025-11-26 Devboard Kicad Files
2025-11-26 Update README with additional project details
    Added details about the cyberpunk logo, journal link, and PCB ordering instructions.
2025-11-30 Enhance README with schematic and PCB images
    Added schematic and PCB screenshots to README.
